# Keil uVision project TEST01.uvprojx, settings and files
target TEST01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST01
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\core;..\..\project;..\..\fwlib_3_5_0\inc;..\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../../core/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ../: system_stm32f10x.c
    ../USER/src/: bsp_esp8266.c Delay.c main.c stm32f10x_it.c System_Init.c Traffic_Light.c
  group FWLIB_3_5_0
    ../../fwlib_3_5_0/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
